# Keil uVision project VFD_FW.uvprojx, settings and files
target VFD_FW (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: VFD_FW +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../pt-1.4
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/User/Core
    ../Core/Inc/: work_logic.h BME280.h i2c_dev.h LoRa1.h glonass.h
    ../Core/Src/: work_logic.c BME280.c i2c_dev.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c LoRa1.c glonass.c
software components: CMSIS:CORE 4.3.0
